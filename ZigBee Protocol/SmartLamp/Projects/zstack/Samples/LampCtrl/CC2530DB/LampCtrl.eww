<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LampCtrl.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LampCtrl</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>LampCtrl</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>LampCtrl</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


